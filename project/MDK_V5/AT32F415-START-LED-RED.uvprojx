# Keil uVision project AT32F415-START-LED-RED.uvprojx, settings and files
target AT32F415-START-LED-RED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AT32F415-START-LED-RED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_wk_config.c at32f415_int.c display.c fonts.c ili9341.c st7789.c images.c gif.c
  group firmware
    ../../libraries/drivers/src/: at32f415_crm.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_pwc.c at32f415_dma.c at32f415_spi.c at32f415_tmr.c at32f415_exint.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
